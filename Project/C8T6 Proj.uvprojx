# Keil uVision project C8T6 Proj.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: C8T6 Proj +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\src;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\User;..\User\LED;..\User\Beep;..\User\delay;..\User\ADC;..\User\USART;..\User\OLED;..\User\PWM;..\User\KEY;..\User\KEY_EXTI;..\User\dht11;..\User\ds1302;..\User\NET;..\User\NET\Cjison;..\User\NET\esp8266;..\User\NET\MQTT;..\User\NET\onenet;..\User\USART;..\User\HC_SR501
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group NET
    ../User/NET/Cjison/: cJSON.c
    ../User/NET/esp8266/: esp8266.c
    ../User/NET/MQTT/: MqttKit.c
    ../User/NET/onenet/: onenet.c
  group User
    ../User/: main.c
    ../User/LED/: bsp_LED.c
    ../User/Beep/: beep.c
    ../User/delay/: Delay.c
    ../User/USART/: bsp_USART.c usart.c
    ../User/OLED/: OLED.c
    ../User/PWM/: bsp_pwm.c
    ../User/KEY/: bsp_KEY.c
    ../User/KEY_EXTI/: bsp_KEY_EXTI.c
    ../User/dht11/: bsp_dht11.c
    ../User/ds1302/: bsp_ds1302.c
    ../User/HC_SR501/: HC_SR501.c
    ../User/ADC/: ADC.c
  group CMSIS
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Libraries
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_flash.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_dbgmcu.c stm32f10x_dac.c stm32f10x_crc.c stm32f10x_cec.c stm32f10x_can.c stm32f10x_bkp.c stm32f10x_adc.c misc.c stm32f10x_wwdg.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_sdio.c stm32f10x_rtc.c stm32f10x_rcc.c stm32f10x_pwr.c stm32f10x_iwdg.c stm32f10x_i2c.c stm32f10x_gpio.c stm32f10x_fsmc.c
